#include <REGX52.H>

void main()
{
	P0=0x00;
	P2=0xff;  //初始化
	while(1)
	{
	if(P3_1==0)  //开关一关闭
	{
	P2=0xfe;       //赋值低电平
	P0=0x06;      //1对应的16进制
	}
	else if(P3_0==0) //开关二关闭
	{
		P2=0xfd;      //赋值低电平
		P0=0x5B;     //2对应的16进制
	}
	else if(P3_2==0)
	{
		P2=0xfb;      //赋值低电平
		P0=0x4F;     //3对应的16进制
	}
	else if(P3_3==0)
	{
		P2=0xf7;      //赋值低电平
		P0=0x66;     //4对应的16进制
	}
	}
}